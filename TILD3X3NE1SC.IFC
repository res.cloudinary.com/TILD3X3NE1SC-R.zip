Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: TILD3X3NE1SC.IFC
Time: 2023-11-27T21:50:15
Author: Windows User
Written by: SwIFC
Made in: SolidWorks 2020

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: 4240-002396-XXX-1-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-R; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 4240-002396-XXX-2-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-R; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 4250-004502-XXX-1-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-R; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 4250-004502-XXX-2-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-R; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 4250-004503-XXX-1-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-R; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 4250-004503-XXX-2-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-R; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 4250-004940-XXX-1/4250-004940-1-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-R; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 4250-004940-XXX-1/8206-002026-2-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-R; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 4250-004940-XXX-1/8206-002026-3-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-R; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 4250-004940-XXX-1/8206-002026-4-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-R; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 4250-004940-XXX-1/8206-002026-5-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-R; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 4250-004940-XXX-2/4250-004940-1-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-R; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 4250-004940-XXX-2/8206-002026-2-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-R; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 4250-004940-XXX-2/8206-002026-3-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-R; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 4250-004940-XXX-2/8206-002026-4-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-R; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 4250-004940-XXX-2/8206-002026-5-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-R; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 4250-005840-XXX-4-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 4250-005840-XXX-5-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 4250-005841-XXX-1/4250-005841-1-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-R; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 4250-005841-XXX-1/8206-002028-10-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-R; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 4250-005841-XXX-1/8206-002028-11-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-R; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 4250-005841-XXX-1/8206-002028-12-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-R; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 4250-005841-XXX-1/8206-002028-17-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-R; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 4250-005841-XXX-1/8206-002028-18-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-R; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 4250-005841-XXX-1/8206-002028-19-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-R; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 4250-005841-XXX-1/8206-002028-20-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-R; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 4250-005841-XXX-1/8206-002028-21-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-R; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 4250-005841-XXX-1/8206-002028-22-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-R; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 4250-005841-XXX-1/8206-002028-23-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-R; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 4250-005841-XXX-1/8206-002028-24-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-R; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 4250-005841-XXX-1/8206-002028-9-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-R; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 8201-000032-1-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-R; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 8201-000032-2-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-R; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 8201-000032-3-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-R; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 8201-000032-4-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-R; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 8201-000032-5-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-R; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 8201-000032-6-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-R; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 8201-000032-7-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-R; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 8201-000032-8-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-R; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 8201-000063-2-solid1 (9)
In: Default Storey
SolidWorks Custom Properties - Number: NANOLUMENS ENGAGE SERIES WITH SCREWS; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 8201-000063-3-solid1 (9)
In: Default Storey
SolidWorks Custom Properties - Number: NANOLUMENS ENGAGE SERIES WITH SCREWS; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 8201-000063-4-solid1 (9)
In: Default Storey
SolidWorks Custom Properties - Number: NANOLUMENS ENGAGE SERIES WITH SCREWS; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 8201-000063-5-solid1 (9)
In: Default Storey
SolidWorks Custom Properties - Number: NANOLUMENS ENGAGE SERIES WITH SCREWS; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 8201-000471-1-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-R; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 8201-000471-2-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-R; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 8201-000471-3-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-R; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 8201-000471-4-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-R; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 8201-000471-5-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-R; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 8201-000471-6-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-R; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 8201-000471-7-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-R; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 8201-000471-8-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-R; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 8201-003487-1-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-R; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 8201-003487-2-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-R; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 8201-003487-3-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-R; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 8201-003487-4-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-R; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 8203-000036-1-solid1 (9)
In: Default Storey
SolidWorks Custom Properties - Number: NANOLUMENS ENGAGE SERIES WITH SCREWS; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 8203-000036-2-solid1 (9)
In: Default Storey
SolidWorks Custom Properties - Number: NANOLUMENS ENGAGE SERIES WITH SCREWS; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 8203-000036-3-solid1 (9)
In: Default Storey
SolidWorks Custom Properties - Number: NANOLUMENS ENGAGE SERIES WITH SCREWS; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 8203-000036-4-solid1 (9)
In: Default Storey
SolidWorks Custom Properties - Number: NANOLUMENS ENGAGE SERIES WITH SCREWS; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 8203-002051-5-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-R; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 8203-002051-6-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-R; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 8203-002051-7-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-R; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 8203-002051-8-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-R; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 8204-003175-1-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-R; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 8204-003175-2-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-R; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 8204-003176-1-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-R; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 8204-003176-2-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-R; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 8204-003423-1-solid1 (9)
In: Default Storey
SolidWorks Custom Properties - Number: NANOLUMENS ENGAGE SERIES WITH SCREWS; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 8204-003423-2-solid1 (9)
In: Default Storey
SolidWorks Custom Properties - Number: NANOLUMENS ENGAGE SERIES WITH SCREWS; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 8204-003423-3-solid1 (9)
In: Default Storey
SolidWorks Custom Properties - Number: NANOLUMENS ENGAGE SERIES WITH SCREWS; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 8204-003423-4-solid1 (9)
In: Default Storey
SolidWorks Custom Properties - Number: NANOLUMENS ENGAGE SERIES WITH SCREWS; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 8205-002388-XXX-10-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-R; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 8205-002388-XXX-11-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-R; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 8205-002388-XXX-12-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-R; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 8205-002388-XXX-13-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-R; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 8205-002388-XXX-14-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-R; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 8205-002388-XXX-15-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-R; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 8205-002388-XXX-16-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-R; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 8205-002388-XXX-9-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-R; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 8205-002433-XXX-1-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-R; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 8205-002433-XXX-2-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-R; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 8205-002433-XXX-3-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-R; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 8205-002433-XXX-4-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-R; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 8715-002006-1-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-R; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-004794-XXX-2/4250-004354-1-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-R; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-004794-XXX-2/4250-004355-1-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-R; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-004794-XXX-2/8204-003213-1-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-R; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-004794-XXX-3/4250-004354-1-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-R; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-004794-XXX-3/4250-004355-1-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-R; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-004794-XXX-3/8204-003213-1-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-R; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005670-XXX-1/4240-002396-XXX-1-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005670-XXX-1/4240-002396-XXX-2-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005670-XXX-1/4250-004502-XXX-1-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005670-XXX-1/4250-004502-XXX-2-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005670-XXX-1/4250-004503-XXX-1-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005670-XXX-1/4250-004503-XXX-2-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005670-XXX-1/4250-004940-XXX-1/4250-004940-1-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005670-XXX-1/4250-004940-XXX-1/8206-002026-2-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005670-XXX-1/4250-004940-XXX-1/8206-002026-3-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005670-XXX-1/4250-004940-XXX-1/8206-002026-4-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005670-XXX-1/4250-004940-XXX-1/8206-002026-5-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005670-XXX-1/4250-004940-XXX-2/4250-004940-1-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005670-XXX-1/4250-004940-XXX-2/8206-002026-2-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005670-XXX-1/4250-004940-XXX-2/8206-002026-3-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005670-XXX-1/4250-004940-XXX-2/8206-002026-4-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005670-XXX-1/4250-004940-XXX-2/8206-002026-5-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005670-XXX-1/4250-005841-XXX-1/4250-005841-1-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005670-XXX-1/4250-005841-XXX-1/8206-002028-10-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005670-XXX-1/4250-005841-XXX-1/8206-002028-11-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005670-XXX-1/4250-005841-XXX-1/8206-002028-12-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005670-XXX-1/4250-005841-XXX-1/8206-002028-17-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005670-XXX-1/4250-005841-XXX-1/8206-002028-18-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005670-XXX-1/4250-005841-XXX-1/8206-002028-19-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005670-XXX-1/4250-005841-XXX-1/8206-002028-20-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005670-XXX-1/4250-005841-XXX-1/8206-002028-21-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005670-XXX-1/4250-005841-XXX-1/8206-002028-22-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005670-XXX-1/4250-005841-XXX-1/8206-002028-23-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005670-XXX-1/4250-005841-XXX-1/8206-002028-24-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005670-XXX-1/4250-005841-XXX-1/8206-002028-9-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005670-XXX-1/8201-000032-1-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005670-XXX-1/8201-000032-2-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005670-XXX-1/8201-000032-3-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005670-XXX-1/8201-000032-4-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005670-XXX-1/8201-000032-5-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005670-XXX-1/8201-000032-6-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005670-XXX-1/8201-000032-7-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005670-XXX-1/8201-000032-8-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005670-XXX-1/8201-000471-1-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005670-XXX-1/8201-000471-2-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005670-XXX-1/8201-000471-3-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005670-XXX-1/8201-000471-4-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005670-XXX-1/8201-000471-5-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005670-XXX-1/8201-000471-6-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005670-XXX-1/8201-000471-7-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005670-XXX-1/8201-000471-8-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005670-XXX-1/8201-003487-1-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005670-XXX-1/8201-003487-2-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005670-XXX-1/8201-003487-3-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005670-XXX-1/8201-003487-4-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005670-XXX-1/8203-002051-5-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005670-XXX-1/8203-002051-6-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005670-XXX-1/8203-002051-7-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005670-XXX-1/8203-002051-8-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005670-XXX-1/8204-003175-1-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005670-XXX-1/8204-003175-2-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005670-XXX-1/8204-003176-1-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005670-XXX-1/8204-003176-2-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005670-XXX-1/8205-002388-XXX-10-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005670-XXX-1/8205-002388-XXX-11-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005670-XXX-1/8205-002388-XXX-12-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005670-XXX-1/8205-002388-XXX-13-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005670-XXX-1/8205-002388-XXX-14-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005670-XXX-1/8205-002388-XXX-15-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005670-XXX-1/8205-002388-XXX-16-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005670-XXX-1/8205-002388-XXX-9-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005670-XXX-1/8205-002433-XXX-1-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005670-XXX-1/8205-002433-XXX-2-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005670-XXX-1/8205-002433-XXX-3-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005670-XXX-1/8205-002433-XXX-4-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005670-XXX-1/8715-002006-1-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005670-XXX-1/9200-004795-XXX-1/4250-004355-1-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005670-XXX-1/9200-004795-XXX-1/4250-004356-1-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005670-XXX-1/9200-004795-XXX-1/8204-003213-1-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005670-XXX-1/9200-004795-XXX-2/4250-004355-1-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005670-XXX-1/9200-004795-XXX-2/4250-004356-1-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005670-XXX-1/9200-004795-XXX-2/8204-003213-1-solid1
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-L; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/4240-002396-XXX-1-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/4240-002396-XXX-2-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/4250-004502-XXX-1-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/4250-004502-XXX-2-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/4250-004503-XXX-1-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/4250-004503-XXX-2-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/4250-005154-XXX-1/4250-005154-1-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/4250-005154-XXX-1/8206-002028-1-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/4250-005154-XXX-1/8206-002028-2-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/4250-005154-XXX-1/8206-002028-3-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/4250-005154-XXX-1/8206-002028-4-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/4250-005154-XXX-2/4250-005154-1-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/4250-005154-XXX-2/8206-002028-1-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/4250-005154-XXX-2/8206-002028-2-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/4250-005154-XXX-2/8206-002028-3-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/4250-005154-XXX-2/8206-002028-4-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/4250-005842-XXX-1/4250-005842-1-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/4250-005842-XXX-1/8206-002028-10-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/4250-005842-XXX-1/8206-002028-11-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/4250-005842-XXX-1/8206-002028-12-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/4250-005842-XXX-1/8206-002028-28-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/4250-005842-XXX-1/8206-002028-29-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/4250-005842-XXX-1/8206-002028-30-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/4250-005842-XXX-1/8206-002028-31-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/4250-005842-XXX-1/8206-002028-32-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/4250-005842-XXX-1/8206-002028-33-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/4250-005842-XXX-1/8206-002028-34-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/4250-005842-XXX-1/8206-002028-35-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/4250-005842-XXX-1/8206-002028-36-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/4250-005842-XXX-1/8206-002028-37-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/4250-005842-XXX-1/8206-002028-38-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/4250-005842-XXX-1/8206-002028-39-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/4250-005842-XXX-1/8206-002028-40-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/4250-005842-XXX-1/8206-002028-41-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/4250-005842-XXX-1/8206-002028-42-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/4250-005842-XXX-1/8206-002028-43-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/4250-005842-XXX-1/8206-002028-9-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/8201-000032-1-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/8201-000032-2-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/8201-000032-3-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/8201-000032-4-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/8201-000032-5-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/8201-000032-6-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/8201-000032-7-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/8201-000032-8-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/8201-000471-1-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/8201-000471-2-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/8201-000471-3-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/8201-000471-4-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/8201-000471-5-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/8201-000471-6-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/8201-000471-7-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/8201-000471-8-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/8201-003487-1-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/8201-003487-2-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/8201-003487-3-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/8201-003487-4-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/8203-002051-5-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/8203-002051-6-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/8203-002051-7-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/8203-002051-8-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/8204-003175-1-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/8204-003175-2-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/8204-003176-1-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/8204-003176-2-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/8205-002388-XXX-10-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/8205-002388-XXX-11-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/8205-002388-XXX-12-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/8205-002388-XXX-13-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/8205-002388-XXX-14-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/8205-002388-XXX-15-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/8205-002388-XXX-16-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/8205-002388-XXX-9-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/8205-002433-XXX-1-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/8205-002433-XXX-2-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/8205-002433-XXX-3-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/8205-002433-XXX-4-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/8715-002006-1-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/9200-004794-XXX-2/4250-004354-1-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/9200-004794-XXX-2/4250-004355-1-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/9200-004794-XXX-2/8204-003213-1-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/9200-004794-XXX-3/4250-004354-1-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/9200-004794-XXX-3/4250-004355-1-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: 9200-005671-XXX-2/9200-004794-XXX-3/8204-003213-1-solid1 (2)
In: Default Storey
SolidWorks Custom Properties - Number: TILD1X3NE1-M; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: NANOLUMENS ENGAGE DEPTH ADJUST SCREW-1-solid1 (9)
In: Default Storey
SolidWorks Custom Properties - Number: NANOLUMENS ENGAGE SERIES WITH SCREWS; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: NANOLUMENS ENGAGE DEPTH ADJUST SCREW-2-solid1 (9)
In: Default Storey
SolidWorks Custom Properties - Number: NANOLUMENS ENGAGE SERIES WITH SCREWS; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: NANOLUMENS ENGAGE DEPTH ADJUST SCREW-3-solid1 (9)
In: Default Storey
SolidWorks Custom Properties - Number: NANOLUMENS ENGAGE SERIES WITH SCREWS; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: NANOLUMENS ENGAGE DEPTH ADJUST SCREW-4-solid1 (9)
In: Default Storey
SolidWorks Custom Properties - Number: NANOLUMENS ENGAGE SERIES WITH SCREWS; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: NANOLUMENS ENGAGE HOUSING-1-solid1 (9)
In: Default Storey
SolidWorks Custom Properties - Number: NANOLUMENS ENGAGE SERIES WITH SCREWS; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: NANOLUMENS ENGAGE SERIES LED MODULES-1-solid1 (9)
In: Default Storey
SolidWorks Custom Properties - Number: NANOLUMENS ENGAGE SERIES WITH SCREWS; DrawnDate: 2/2/2023; DrawnBy: JAB

# IfcBuildingElementProxy: NONE (22)
In: Default Storey
SolidWorks Custom Properties - Nomenclature: TILSC27U3; Part Number: TILSC27U3; Source: NOT_KNOWN; Revision: ANY

# IfcBuildingElementProxy: TILVAB2_NE1-L (4)
In: Default Storey
Material: 12 GAUGE .1046" OR 2.5 mm .0984 ASTM A1008/A1011 & A568 CS TYPE B or JIS G3131 SPHC OR JIS G3141 SPCC
SolidWorks Custom Properties - UNIT_OF_MEASURE: - none -; Material: 12 GAUGE .1046" OR 2.5 mm .0984 ASTM A1008/A1011 & A568 CS TYPE B or JIS G3131 SPHC OR JIS G3141 SPCC; Weight: 0.11199; Volume: 0.39434; Number: TILVAB2_NE1-L; DrawnDate: 10/18/2021; DrawnBy: JAB; Description: LED, ABSEN N-PLUS, VERTICAL CONNECTOR; Status: JAB 06/04/2021 - REV - PENDING APPROVAL ON ECO 500024202

# IfcBuildingElementProxy: TILVAB2_NE1-R (4)
In: Default Storey
Material: 12 GAUGE .1046" OR 2.5 mm .0984 ASTM A1008/A1011 & A568 CS TYPE B or JIS G3131 SPHC OR JIS G3141 SPCC
SolidWorks Custom Properties - UNIT_OF_MEASURE: - none -; Material: 12 GAUGE .1046" OR 2.5 mm .0984 ASTM A1008/A1011 & A568 CS TYPE B or JIS G3131 SPHC OR JIS G3141 SPCC; Weight: 0.11199; Volume: 0.39434; Number: TILVAB2_NE1-R; DrawnDate: 10/18/2021; DrawnBy: JAB; Description: LED, ABSEN N-PLUS, VERTICAL CONNECTOR; Status: JAB 06/04/2021 - REV - PENDING APPROVAL ON ECO 500024202

# IfcElementAssembly: TILD3X3NE1SC
In: Default Storey
SolidWorks Custom Properties - Design: TILD3X3NE1SC; CreatedOn: 11/27/2023 14:25:00; Project: 15689; ProjectName: Chief TiLED Kits; DisplayMFG: NANOLUMENS; DisplayModel: Engage Series (NXT, Pro); Company URL: www.legrandav.com; Mount Manufacturer: Legrand AV – Chief; Copyright: Copyright © Legrand AV; Product Series URL: https://www.legrandav.com/resources/360_product_overviews/tiled; DisplayQTY: 9; DisplayConfig: 3 X 3; OverallSize: 3.32 x 6.6000 FT / 171.80 LB; OverallMountSize: 3.2800 x 6.1300 FT / 39.14 LB
PSet_Mass_Property - Mass Measure: 16.1226; Area Measure: 12.0781 m2; Volume Measure: 0.0446716 m3
